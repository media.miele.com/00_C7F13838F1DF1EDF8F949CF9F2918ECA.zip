Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 3007a4b3-1df2-44ef-b4dd-740712c7c813, NumberOfSaves: 1]
File name: 0001
Time: 2024-07-01T11:54:26+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 07001680_D_KM6024:26602452_D_7001680_KM6024, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - Reference: 26602452_D_7001680_KM6024; sets with these values: 2
